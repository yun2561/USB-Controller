# Keil uVision project USB Controller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.3.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB Controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F350
  c misc: --diag_suppress=3108
  c include: ..\Driver;..\Utilties;..\Common;..\Middleware;..\Bootloader;..\Fwlib\CMSIS\GD\GD32F3x0\Include;..\Fwlib\CMSIS;..\Fwlib\GD32F3x0_standard_peripheral\Include;..\Fwlib\GD32F3x0_usbfs_library\device\core\Include;..\Fwlib\GD32F3x0_usbfs_library\device\core\Source;..\Fwlib\GD32F3x0_usbfs_library\driver\Include;..\Fwlib\GD32F3x0_usbfs_library\driver\Source;..\Fwlib\GD32F3x0_usbfs_library\ustd\common;..\Fwlib\GD32F3x0_usbfs_library\ustd\class\msc;..\Fwlib\GD32F3x0_usbfs_library\host\core\Include;..\Fwlib\GD32F3x0_usbfs_library\host\core\Source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Fwlib/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Application
    ../Application/: main.c ui_manager.h ui_manager.c usb_midi_bridge.c usb_midi_bridge.h midi_api.c midi_api.h
  group Bootloader
    ../Bootloader/: boot_main.c
  group Driver
    ../Driver/: bsp_system.h bsp_system.c gd32f3x0_it.c gd32f3x0_it.h gd32f3x0_libopt.h bsp_uart_midi.c bsp_uart_midi.h bsp_fmc.h bsp_fmc.c bsp_usb_midi.h bsp_usb_midi.c usb_midi_desc.c usb_midi_class.h usb_midi_class.c usb_conf.h drv_usb_hw.c
  group Fwlib
    ../Fwlib/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group JLinkPrintf
    ../JLinkPrintf/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Middleware
    ../Middleware/: crc_engine.h crc_engine.c ring_buffer.h ring_buffer.c midi_parser.h midi_parser.c usb_midi_codec.h usb_midi_codec.c midi_router.h midi_router.c sysex_assembler.h sysex_assembler.c dfu_engine.h dfu_engine.c
  group Common
    ../Common/: common_types.h
  group CMSIS
    ../Fwlib/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group USB_Drivers
    ../Fwlib/GD32F3x0_usbfs_library/driver/Source/: drv_usbd_int.c drv_usb_core.c drv_usb_dev.c
    ../Fwlib/GD32F3x0_usbfs_library/driver/Include/: drv_usb_hw.h
  group USB_Device
    ../Fwlib/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
